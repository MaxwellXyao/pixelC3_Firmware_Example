# Keil uVision project Template.uvproj, settings and files
target PixelC3.x (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM;..\PIXELC_HARDWARE;..\PIXELC_HARDWARE\pixelC_HW_SDcard_FATFS0.09a;..\SOLGUI;..\SOLGUI\Font;..\PIXELC_HARDWARE\pixelC_HW_SDcard_FATFS0.09b;..\PIXELC_HARDWARE\pixelC_HW_SDcard_FATFS0.09b\option
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/: bit.c strprintf.c sys.c delay.c simuspi.c simui2c.c
  group SOLGUI
    ../SOLGUI/Font/: Font4x6_ASCII.c Font6x8_ASCII.c Font8x8_ASCII.c Font8x10_ASCII.c
    ../SOLGUI/: SOLGUI_Hardware.c SOLGUI_Common.c SOLGUI_Printf.c SOLGUI_GBasic.c SOLGUI_Picture.c SOLGUI_Menu.c SOLGUI_Widget.c
  group FATFS
    ../PIXELC_HARDWARE/pixelC_HW_SDcard_FATFS0.09b/: diskio.c ff.c
  group PIXELC_HARDWARE
    ../PIXELC_HARDWARE/: pixelC_HW_flagLight.c pixelC_HW_OLED.c pixelC_HW_Key.c pixelC_HW_Flash.c pixelC_HW_SDcard.c pixelC_HW_Port.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
